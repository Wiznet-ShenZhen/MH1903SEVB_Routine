# Keil uVision project Template.uvprojx, settings and files
target Megahunt MH903S (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Template +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\Libraries\CMSIS\Device\MegaHunt\mhscpu\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\MHSCPU_Driver\inc;..\..\User\MH1903SEVB_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../../Libraries/CMSIS/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group MHSCPU_Driver
    ../../Libraries/MHSCPU_Driver/src/: mhscpu_adc.c mhscpu_cache.c mhscpu_crc.c mhscpu_dac.c mhscpu_dcmi.c mhscpu_dma.c mhscpu_exti.c mhscpu_gpio.c mhscpu_hspim.c mhscpu_i2c.c mhscpu_kcu.c mhscpu_lcdi.c mhscpu_otp.c mhscpu_qspi.c mhscpu_rtc.c mhscpu_spi.c mhscpu_sysctrl.c mhscpu_timer.c mhscpu_trng.c mhscpu_uart.c mhscpu_wdt.c misc.c
  group MH1903SEVB_Driver
    ../../User/MH1903SEVB_Driver/src/: delay.c flash.c md5.c pipe.c socket.c sysc.c usart.c w5500.c
  group USER
    ../../User/: main.c mhscpu_it.c
